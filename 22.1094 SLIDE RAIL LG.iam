# Autodesk Inventor assembly: 22.1094 SLIDE RAIL LG
## iProperties
Created: 2007-06
Part Number: 22.1094 SLIDE RAIL LG
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
